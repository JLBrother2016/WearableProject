# Keil uVision project WearableDevice.uvprojx, settings and files
target WearableDevice (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: WearableDevice +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F4XX,USE_USB_OTG_FS,USE_EMBEDDED_PHY,ARM_MATH_CM4
  c include: ..\FatFs\src;.\driver\include;.\configure\include;.\application\include;..\rt-thread-2.0.0\include;..\rt-thread-2.0.0\components\finsh;..\rt-thread-2.0.0\components\drivers\include;..\STM32_STDPERIPH_DRIVER\CMSIS\Include;..\STM32_STDPERIPH_DRIVER\STM32F4xx_StdPeriph_Driver\inc;..\STM32_STDPERIPH_DRIVER\STM32F4xx_USB_Library\STM32_USB_Device_Library\Core\inc;..\STM32_STDPERIPH_DRIVER\STM32F4xx_USB_Library\STM32_USB_Device_Library\Class\msc\inc;..\STM32_STDPERIPH_DRIVER\STM32F4xx_USB_Library\STM32_USB_OTG_Driver\inc;..\STM32_STDPERIPH_DRIVER\STM32F4xx_USB_Library\STM32_USB_HOST_Library\Core\inc;.\driver\lowpower;..\STM32_STDPERIPH_DRIVER\CMSIS\Include;.\driver\algorithm\Feature
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Applications
    ./application/: application.c easy_rtthread.c startup.c stm32f4xx_it.c audio.c thread_key.c thread_oled.c thread_mpu6050.c thread_battery.c thread_sensors.c thread_file.c thread_audio.c thread_dsp.c
    ./driver/app/: thread_wifi.c
  group Drivers
    ./driver/adc/: battery.c
    ./driver/board/: board.c
    ./driver/button/: key.c
    ./driver/codec/: wm8978.c
    ./driver/cpu/: cpuusage.c
    ./driver/dma/: dma.c
    ./driver/gpio/: pin.c
    ./driver/i2c/: i2c.c
    ./driver/i2s/: i2s.c
    ./driver/include/: fonts.h
    ./driver/led/: led.c
    ./driver/screen/: oled.c
    ./driver/sdio/: sdio_sd.c
    ./driver/sensors/: bh1750.c bmp180.c mpu6050.c si7021.c
    ./driver/uart/: serial.c usart.c
    ./driver/usb/: usb_bsp.c usb_it.c usbd_desc.c usbd_storage_msd.c usbd_usr.c
    ./driver/wav/: wav.c
    ./driver/rtc/: rtc.c
    ./driver/lowpower/: lowpower.c
    ./driver/watchdog/: watchdog.c
    ./driver/errlog/: fatfserr.c
  group STM32_StdPeriph
    ../STM32_STDPERIPH_DRIVER/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group Middleware
    ./driver/tool/: portal.c pipe.c ringbuffer.c dataqueue.c workqueue.c completion.c
  group Kernel
    ../rt-thread-2.0.0/src/: clock.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c module.c object.c scheduler.c slab.c thread.c timer.c
    ../rt-thread-2.0.0/libcpu/arm/cortex-m4/: cpuport.c context_rvds.S
  group Finsh
    ../rt-thread-2.0.0/components/finsh/: cmd.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_token.c finsh_var.c finsh_vm.c msh.c msh_cmd.c shell.c symbol.c
  group Configuration
    ./configure/include/: config.h ffconf.h rtconfig.h stm32f4xx.h stm32f4xx_conf.h system_stm32f4xx.h
    ./configure/: startup_stm32f4xx.s system_stm32f4xx.c
  group USB_Library
    ../STM32_STDPERIPH_DRIVER/STM32F4xx_USB_Library/STM32_USB_Device_Library/Core/src/: usbd_core.c usbd_ioreq.c usbd_req.c
    ../STM32_STDPERIPH_DRIVER/STM32F4xx_USB_Library/STM32_USB_Device_Library/Class/msc/src/: usbd_msc_bot.c usbd_msc_core.c usbd_msc_data.c usbd_msc_scsi.c
    ../STM32_STDPERIPH_DRIVER/STM32F4xx_USB_Library/STM32_USB_OTG_Driver/src/: usb_core.c usb_dcd.c usb_dcd_int.c
  group FatFs
    ../FatFs/src/: diskio.c ff.c
    ../FatFs/src/option/: cc936.c
  group DSP_Lib
    ../STM32_STDPERIPH_DRIVER/CMSIS/Lib/ARM/: arm_cortexM4lf_math.lib
  group DSP_FFT
    ./driver/algorithm/ENERGY/: window.c
    ./driver/algorithm/Feature/: feature.c
